options:
  parameters:
    author: bimapancara
    generate_options: qt_gui
    id: DirectionArrivalPeakReceive
    output_language: python
    title: DoA Peak Receive
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    comment: Bandwidth
    value: 2000e3 * 3
  states: {}
- name: c
  id: variable
  parameters:
    comment: Speed of Light
    value: sc.constants.c
  states: {}
- name: d
  id: variable
  parameters:
    comment: Antenna Rx Distance
    value: wavelength * 0.5
  states: {}
- name: d_m
  id: variable
  parameters:
    comment: |-
      Antenna Rx Distance
      in mm
    value: d*1000
  states: {}
- name: freq_center
  id: variable
  parameters:
    comment: Center Frequency
    value: 2.3e9
  states: {}
- name: gain
  id: variable
  parameters:
    comment: Rx Gain
    value: '50'
  states: {}
- name: phase_cal
  id: variable_qtgui_range
  parameters:
    comment: Phase Calibration due to cable length and any other
    label: Phase Cal
    start: '-180'
    step: '2'
    stop: '180'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 64e3
  states: {}
- name: signal_freq
  id: variable
  parameters:
    comment: |-
      Frequency of the
       signal being transmit
    value: 2000e3
  states: {}
- name: wavelength
  id: variable
  parameters:
    comment: |-
      Wavelength of 
      Frequency Center
    value: c / freq_center
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    comment: Calibration
    is_radians: 'True'
    shift: phase_cal
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\nimport scipy.constants as const\nimport numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    \"\"\"Calculate Theta from Phase Difference\"\"\"\n\n    def __init__(self, antenna_space=1.0, center_frequency=1.0):\n        gr.sync_block.__init__(\n            self,\n            name='Calculate Theta',\n            in_sig=[np.complex64, np.complex64],  # Expecting two complex signals\n            out_sig=[np.float32]  # Output theta in degrees\n        )\n        self.antenna_space = antenna_space\n        self.center_frequency = center_frequency\n\n    def work(self, input_items, output_items):\n        \"\"\"Compute Theta from Phase Difference\"\"\"\n        # Extract Rx0 and Rx1\n        Rx0 = input_items[0]\n        Rx1 = input_items[1]\n\n        # Compute Phase Difference\n        phase_diff = np.angle(Rx1) - np.angle(Rx0)  # Phase difference in radians\n\n        # Convert phase difference to degrees\n        phase_diff_deg = np.rad2deg(phase_diff)\n\n        # Compute arcsin argument\n        d = self.antenna_space\n        f = self.center_frequency\n        arcsin_arg = np.deg2rad(phase_diff_deg) * const.c / (2 * np.pi * f * d)\n\n        # Clip values to avoid invalid arcsin inputs\n        arcsin_arg = np.clip(arcsin_arg, -1, 1)\n\n        # Compute Theta\n        output_items[0][:] = np.rad2deg(np.arcsin(arcsin_arg))\n        return len(output_items[0])\n\n\n\n\n"
    antenna_space: d
    center_frequency: freq_center
  states: {}
- name: import_0
  id: import
  parameters:
    comment: Import Numpy
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    comment: Import Scipy
    imports: import scipy as sc
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '180'
    min: '-180'
    name: '"Steering Angle"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: green
    label1: Element 0 I
    label2: Element 0 Q
    label3: Element 1 I
    label4: Element 1 Q
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: bandwidth
    bw1: bandwidth
    center_freq0: freq_center
    center_freq1: freq_center
    gain0: gain
    gain1: gain
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49200
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_phase_shift_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_phase_shift_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [zeromq_sub_source_1, '0', epy_block_0, '1']
- [zeromq_sub_source_1, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
