options:
  parameters:
    author: bimapancara
    generate_options: qt_gui
    id: AoAcalculation
    output_language: python
    title: Angle Of Arrival
  states: {}

blocks:
- name: array_space
  id: variable
  parameters:
    value: 0.5*wavelength
  states: {}
- name: c
  id: variable
  parameters:
    value: 3e8
  states: {}
- name: freq
  id: variable
  parameters:
    value: 5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: c/freq
  states: {}
- name: AoA
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '-100'
    name: '"Angle of Arrival"'
    type: float
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr



      class blk(gr.sync_block):  
          """Angle of Arrival Estimation for a 3-element ULA"""

          def __init__(self, frequency=2.4e9, array_spacing=0.5):  
              """Initialize parameters"""
              gr.sync_block.__init__(
                  self,
                  name='Angle of Arrival Estimation (3-Element ULA)',
                  in_sig=[np.float32, np.float32, np.float32],  # Three phase inputs (already in radians)
                  out_sig=[np.float32]  # Output AoA in degrees
              )
              self.frequency = frequency
              self.array_spacing = array_spacing
              self.wavelength = 3e8 / frequency  # Speed of light / frequency

          def work(self, input_items, output_items):
              """Process incoming phase signals"""
              phi_0 = input_items[0]  # Already in radians
              phi_1 = input_items[1]
              phi_2 = input_items[2]

              num_samples = len(phi_0)
              theta_deg = np.zeros(num_samples, dtype=np.float32)

              for i in range(num_samples):
                  # Compute phase differences (with proper wrapping)
                  delta_phi_1 = np.angle(np.exp(1j * (phi_1[i] - phi_0[i])))  # Between Antenna 0 & 1
                  delta_phi_2 = np.angle(np.exp(1j * (phi_2[i] - phi_1[i])))  # Between Antenna 1 & 2
                  
                  # Take the average phase difference for robustness
                  delta_phi_avg = (delta_phi_1 + delta_phi_2) / 2  

                  # Estimate AoA
                  sin_theta = (self.wavelength * delta_phi_avg) / (2 * np.pi * self.array_spacing)
                  sin_theta = np.clip(sin_theta, -1, 1)  # Prevent NaN errors

                  theta_rad = np.arcsin(sin_theta)
                  theta_deg[i] = np.degrees(theta_rad)

              output_items[0][:] = theta_deg
              return len(output_items[0])
    array_spacing: array_space
    frequency: freq
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49200
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_2
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', epy_block_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_magphase_0_0, '1', epy_block_0, '1']
- [blocks_complex_to_magphase_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '1', epy_block_0, '2']
- [blocks_throttle2_0, '0', AoA, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', blocks_complex_to_magphase_0, '0']
- [zeromq_sub_source_1, '0', blocks_complex_to_magphase_0_0, '0']
- [zeromq_sub_source_2, '0', blocks_complex_to_magphase_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
