options:
  parameters:
    author: bimapancara
    generate_options: qt_gui
    id: CustomizeAoA
    output_language: python
    title: Customizable AoA
  states: {}

blocks:
- name: array_space
  id: variable
  parameters:
    value: 0.5*wavelength
  states: {}
- name: c
  id: variable
  parameters:
    value: 3e8
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: wavelength
  id: variable
  parameters:
    value: c/freq
  states: {}
- name: AoA
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '-100'
    name: '"Angle of Arrival"'
    type: float
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_complex_to_magphase_0_0_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\nclass AoABlock(gr.sync_block):  \n    \"\"\"Angle of Arrival Estimation for a ULA with a dynamic number of elements\"\"\"\n\n    def __init__(self, frequency=2.4e9, array_spacing=0.5, elements=2):  \n        \"\"\"Initialize parameters\"\"\"\n        \n        if elements < 2:\n            raise ValueError(\"Elements must be at least 2.\")\n\n        gr.sync_block.__init__(\n            self,\n            name=\"Angle of Arrival Estimation (ULA)\",\n            in_sig=[np.float32] * elements,  # Dynamically set input signals\n            out_sig=[np.float32]  # Output AoA in degrees\n        )\n\n        self.frequency = frequency\n        self.array_spacing = array_spacing\n        self.wavelength = 3e8 / frequency  # Speed of light / frequency\n        self.elements = elements\n\n    def work(self, input_items, output_items):\n        \"\"\"Process incoming phase signals\"\"\"\n        num_samples = len(input_items[0])\n        theta_deg = np.zeros(num_samples, dtype=np.float32)\n\n        for i in range(num_samples):\n            # Compute phase differences (pairwise)\n            delta_phis = [\n                np.angle(np.exp(1j * (input_items[j+1][i] - input_items[j][i])))\n                for j in range(self.elements - 1)\n            ]\n\n            # Average phase difference\n            delta_phi_avg = np.mean(delta_phis)\n\n            # Estimate AoA\n            sin_theta = (self.wavelength * delta_phi_avg) / (2 * np.pi * self.array_spacing)\n            sin_theta = np.clip(sin_theta, -1, 1)  # Prevent NaN errors\n\n            theta_rad = np.arcsin(sin_theta)\n            theta_deg[i] = np.degrees(theta_rad)\n\n        output_items[0][:] = theta_deg\n        return len(output_items[0])\n\n# Factory function to create a block with the correct number of inputs\ndef create_aoa_block(frequency=2.4e9, array_spacing=0.5, elements=2):\n    return AoABlock(frequency, array_spacing, elements)\n\n"
    array_spacing: array_space
    elements: '4'
    frequency: freq
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49200
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_1
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49202
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_2
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_complex_to_magphase_0_0_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', AoA, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [zeromq_sub_source_0, '0', blocks_complex_to_magphase_0, '0']
- [zeromq_sub_source_1, '0', blocks_complex_to_magphase_0_0, '0']
- [zeromq_sub_source_2, '0', blocks_complex_to_magphase_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
